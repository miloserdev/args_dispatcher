## Config.in
```kconfig
config BR2_PACKAGE_EXAMPLE
	bool "example"
	select BR2_PACKAGE_READLINE
	help
	  example command line tool.
```
